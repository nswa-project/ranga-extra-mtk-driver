## rt2860/Config.in
```kconfig
config RANGA_MTK_RT2860_LED_SYSFS
	depends on PACKAGE_kmod-ranga-mt7620
	string "LED sysfs"
```
